# Keil uVision project UARTPolling.uvprojx, settings and files
target DebugInFlash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.4.0
  cpu: IROM(0x00000000,0x00008000) IRAM(0x10000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LPC8xx +hex
  c flags: Optim=1 OneElfS=1
  c define: CHIP_LPC82X
  c include: .\CM0+;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM0;.\LPC8xx;.\USER_CODE
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group LPC8xx
    ./LPC8xx/: system_LPC8xx.c
    ./LPC8xx/startup/: startup_lpc82x.s
  group USER_CODE
    ./USER_CODE/: main.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
  group FreeRTOS_CORE
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
target DebugInRAM (ARM-ADS)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.4.0
  cpu: as above
  output: LPC8xx +hex
  c flags: Optim=1
  c include: .\CM0+;.\LPC8xx
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
software components: CMSIS:CORE 4.3.0
