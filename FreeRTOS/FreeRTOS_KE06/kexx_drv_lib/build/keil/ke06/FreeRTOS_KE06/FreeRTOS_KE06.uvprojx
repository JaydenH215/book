# Keil uVision project FreeRTOS_KE06.uvprojx, settings and files
target KE06Z-Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKE06Z128xxx4 NXP
  pack: Keil.Kinetis_KExx_DFP.1.7.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FreeRTOS_KE06_Flash
  c define: KEIL FRDM_KE06  CPU_KE06 CMSIS
  c include: ..\..\..\..\src\projects\ke06\FreeRTOS_KE06;..\..\..\..\src\common;..\..\..\..\src\cpu;..\..\..\..\src\cpu\headers;..\..\..\..\src\drivers\uart;..\..\..\..\src\drivers\acmp;..\..\..\..\src\platforms;..\..;..\..\..\..\src\drivers\ics;..\..\..\..\src\drivers\rtc;..\..\..\..\src\drivers\wdog;..\..\..\..\src\drivers\ftm;..\..\..\..\src\drivers\nvm;..\..\..\..\src\drivers\sim;..\..\..\..\src\drivers\spi;..\..\..\..\src\drivers\kbi;..\..\..\..\src\drivers\gpio;..\..\..\..\src\drivers\crc;..\..\..\..\src\drivers\bme;..\..\..\..\src\drivers\iic;..\..\..\..\src\drivers\pit;..\..\..\..\src\drivers\PMC;..\..\..\..\src\drivers\adc;..\..\..\..\src\drivers\pwt;..\..\..\..\src\drivers\bitband;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group common
    ../../../../src/common/: alloc.c assert.c io.c memtest.c stdlib.c
  group cpu
    ../../../../src/cpu/: arm_cm0.c start.c sysinit.c systick.c vectors.c startup_MKE06Z4.s
  group drivers
    ../../../../src/drivers/gpio/: gpio.c
    ../../../../src/drivers/uart/: uart.c
    ../../../../src/drivers/wdog/: wdog.c
    ../../../../src/drivers/sim/: sim.c
    ../../../../src/drivers/rtc/: rtc.c
    ../../../../src/drivers/ics/: ics.c
    ../../../../src/drivers/acmp/: acmp.c
    ../../../../src/drivers/adc/: adc.c
    ../../../../src/drivers/can/: mscan.c
    ../../../../src/drivers/crc/: crc.c
    ../../../../src/drivers/ftm/: ftm.c
    ../../../../src/drivers/iic/: i2c.c
    ../../../../src/drivers/kbi/: kbi.c
    ../../../../src/drivers/nvm/: flash.c
    ../../../../src/drivers/pit/: pit.c
    ../../../../src/drivers/PMC/: pmc.c
    ../../../../src/drivers/pwt/: pwt.c
    ../../../../src/drivers/spi/: spi.c
  group platforms
    ../../../../src/platforms/: ke06_config.h
  group project
    ../../../../src/projects/KE06/FreeRTOS_KE06/: FreeRTOS_KE06.c isr.h
    ./FreeRTOS/include/: FreeRTOSConfig.h
  group FreeRTOS_core
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_port
    ./FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
