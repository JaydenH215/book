# Keil uVision project CAN_Node1WithInt_demo.uvproj, settings and files
target KE06Z-Flash (ARM-ADS)
  device: MKE06Z128xxx4 Freescale Semiconductor
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x3000) IRAM2(0x1FFFF000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: CAN_Node1WithInt_demo_Flash
  c define: KEIL FRDM_KE06  CPU_KE06 CMSIS
  c include: ..\..\..\..\src\projects\ke06\CAN_Node1WithInt_demo;..\..\..\..\src\common;..\..\..\..\src\cpu;..\..\..\..\src\cpu\headers;..\..\..\..\src\drivers\uart;..\..\..\..\src\drivers\acmp;..\..\..\..\src\platforms;..\..;..\..\..\..\src\drivers\ics;..\..\..\..\src\drivers\rtc;..\..\..\..\src\drivers\wdog;..\..\..\..\src\drivers\ftm;..\..\..\..\src\drivers\nvm;..\..\..\..\src\drivers\sim;..\..\..\..\src\drivers\spi;..\..\..\..\src\drivers\kbi;..\..\..\..\src\drivers\gpio;..\..\..\..\src\drivers\crc;..\..\..\..\src\drivers\bme;..\..\..\..\src\drivers\iic;..\..\..\..\src\drivers\pit;..\..\..\..\src\drivers\PMC;..\..\..\..\src\drivers\adc;..\..\..\..\src\drivers\pwt;..\..\..\..\src\drivers\bitband;..\..\..\..\src\drivers\can
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1ffff000 size 0x1000
  group common
    ../../../../src/common/: alloc.c assert.c io.c memtest.c queue.c stdlib.c
  group cpu
    ../../../../src/cpu/: arm_cm0.c start.c sysinit.c systick.c vectors.c startup_MKE06Z4.s
  group drivers
    ../../../../src/drivers/gpio/: gpio.c
    ../../../../src/drivers/uart/: uart.c
    ../../../../src/drivers/wdog/: wdog.c
    ../../../../src/drivers/sim/: sim.c
    ../../../../src/drivers/rtc/: rtc.c
    ../../../../src/drivers/ics/: ics.c
    ../../../../src/drivers/acmp/: acmp.c
    ../../../../src/drivers/adc/: adc.c
    ../../../../src/drivers/can/: mscan.c
    ../../../../src/drivers/crc/: crc.c
    ../../../../src/drivers/ftm/: ftm.c
    ../../../../src/drivers/iic/: i2c.c
    ../../../../src/drivers/kbi/: kbi.c
    ../../../../src/drivers/nvm/: flash.c
    ../../../../src/drivers/pit/: pit.c
    ../../../../src/drivers/PMC/: pmc.c
    ../../../../src/drivers/pwt/: pwt.c
    ../../../../src/drivers/spi/: spi.c
  group platforms
    ../../../../src/platforms/: ke06_config.h
  group project
    ../../../../src/projects/KE06/CAN_Node1WithInt_demo/: CAN_Node1WithInt_demo.c isr.h mscan_api.c
